# Keil uVision project 5_GPIO.uvprojx, settings and files
target stm32f4 (6220000::V6.22::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 5_GPIO
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group app
    ./: main.c
  group drivers
    ./: stm32f4_gpio_driver.h stm32f4_uart_driver.h stm32f4_systick_driver.c stm32f4_systick_driver.h
  group libs
    ./: stm32f4_gpio_lib.h stm32f4_gpio_lib.c stm32f4_uart_lib.h stm32f4_uart_lib.c stm32f4_systick_lib.h stm32f4_systick_lib.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
