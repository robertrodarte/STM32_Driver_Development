# Keil uVision project embed_oop.uvprojx, settings and files
target stm32f4 (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: embed_oop
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group app
    ./: main.c led.c led.h power_led.c power_led.h medical_led.c medical_led.h
  group drivers
    ./: uart.c uart.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
